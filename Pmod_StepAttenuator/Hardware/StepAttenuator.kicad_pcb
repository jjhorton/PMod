# Repository jjhorton/PMod (continued)

## KiCad design PMod_GPS/Hardware/PMod_GPS.kicad_pcb

Parts:
AE1: Antenna; W3213; Mouser No. 673-W3213
J1: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Vertical
U1: NEO-M8M; ublox_NEO

Connections:
1PPS: J1.4, U1.3 (TIMEPULSE)
+3V3: J1.11, J1.12, U1.8 (~RESET), U1.22 (V_BCKP), U1.23 (VCC)
GND: J1.9, J1.10, U1.7 (VDD_USB), U1.10 (GND), U1.12 (GND), U1.13 (GND), U1.24 (GND)
unnamed: AE1.1 (A), U1.11 (RF_IN)
RXD: J1.7, U1.21 (RXD/SPI_MOSI)
SCL: J1.6, U1.19 (SCL/SPI_CLK)
SDA: J1.5, U1.18 (SDA/~SPI_CS)
TXD: J1.8, U1.20 (TXD/SPI_MISO)

Board: 2 copper layers, 47.0 x 17.0 mm, 4 parts (1 on the bottom side), 8 nets.

Other parts of the board:
G1: LOGO; Untitled

## Code that names these connections

File PMod_CC1101/Software/main.c:

#include <stdio.h>
#include <string.h>
#include "pico/stdlib.h"
#include "hardware/spi.h"
#include "pico/binary_info.h"
#include "cc1101.h"

// for PMOD0 output
#define SPI_RX_PIN 0
#define SPI_SCK_PIN 2
#define SPI_TX_PIN 3
#define SPI_CSN_PIN 1

/*
// for PMOD1 output
#define SPI_RX_PIN 16
#define SPI_SCK_PIN 18
#define SPI_TX_PIN 19
#define SPI_CSN_PIN 17
*/

#define READ_BIT 0x80
#define READ_BURST 0xC0

static inline void cs_select() {
    asm volatile("nop \n nop \n nop");
    gpio_put(SPI_CSN_PIN, 0);  // Active low
    asm volatile("nop \n nop \n nop");
}

static inline void cs_deselect() {
    asm volatile("nop \n nop \n nop");
    gpio_put(SPI_CSN_PIN, 1);
    asm volatile("nop \n nop \n nop");
}

// write to a SPI register
static void write_register(uint8_t reg, uint8_t data) {
    uint8_t buf[2];
    buf[0] = reg & 0x7f;  // remove read bit as this is a write
    buf[1] = data;
    cs_select();
    spi_write_blocking(spi0, buf, 2);
    cs_deselect();
    sleep_ms(10);
}

//read from a SPI register
static void read_registers(uint8_t reg, uint8_t *buf, uint16_t len) {
    // For this particular device, we send the device the register we want to read
    // first, then subsequently read from the device. The register is auto incrementing
    // so we don't need to keep sending the register we want, just the first.
    reg |= READ_BIT;
    cs_select();
    spi_write_blocking(spi0, &reg, 1);
    sleep_ms(10);
    spi_read_blocking(spi0, 0, buf, len);
    cs_deselect();
    sleep_ms(10);
}

/* set the radio frequency in Hz */
void set_radio_freq(uint32_t freq) {
	/* the frequency setting is in units of 396.728515625 Hz */

	uint32_t setting = (uint32_t) (freq * .0025206154);
	write_register(CC1101_FREQ2,(setting >> 16) & 0xff);
	write_register(CC1101_FREQ1,(setting >> 8) & 0xff);
	write_register(CC1101_FREQ0,setting & 0xff);

	uint8_t band = BAND_400;

	if ((band == BAND_300 && freq < MID_300) ||
			(band == BAND_400 && freq < MID_400) ||
			(band == BAND_900 && freq < MID_900)){
		/* select low VCO */
		write_register(CC1101_FSCAL2,0x0A);
		}
	else{
		/* select high VCO */
		write_register(CC1101_FSCAL2,0x2A);
		}
	}

// initalise the CC1101
static void setup_cc1101(){
	write_register(CC1101_FSCTRL1,  0x08);
	write_register(CC1101_FSCTRL0,  0x00);
	write_register(CC1101_FREQ2,    F2_433);
	write_register(CC1101_FREQ1,    F1_433);
	write_register(CC1101_FREQ0,    F0_433);
	write_register(CC1101_MDMCFG4,  0x5B);
	write_register(CC1101_MDMCFG3,  0xF8);
	write_register(CC1101_MDMCFG2,  0x03);
	write_register(CC1101_MDMCFG1,  0x22);
	write_register(CC1101_MDMCFG0,  0xF8);
	write_register(CC1101_CHANNR,   0x00);
	write_register(CC1101_DEVIATN,  0x47);
	write_register(CC1101_FREND1,   0xB6);
	write_register(CC1101_FREND0,   0x10);
	write_register(CC1101_MCSM0 ,   0x18);
	write_register(CC1101_FOCCFG,   0x1D);
	write_register(CC1101_BSCFG,    0x1C);
	write_register(CC1101_AGCCTRL2, 0xC7);
	write_register(CC1101_AGCCTRL1, 0x00);
	write_register(CC1101_AGCCTRL0, 0xB2);
	write_register(CC1101_FSCAL3,   0xEA);
	write_register(CC1101_FSCAL2,   0x2A);
	write_register(CC1101_FSCAL1,   0x00);
	write_register(CC1101_FSCAL0,   0x11);
	write_register(CC1101_FSTEST,   0x59);
	write_register(CC1101_TEST2,    0x81);
	write_register(CC1101_TEST1,    0x35);
	write_register(CC1101_TEST0,    0x09);
	write_register(CC1101_IOCFG2,   0x0B); 	//serial clock.synchronous to the data in synchronous serial mode
	write_register(CC1101_IOCFG0,   0x06);  	//asserts when sync word has been sent/received, and de-asserts at the end of the packet
	write_register(CC1101_PKTCTRL1, 0x04);		//two status bytes will be appended to the payload of the packet,including RSSI LQI and CRC OK
									//No address check
	write_register(CC1101_PKTCTRL0, 0x05);		//whitening off;CRC Enable£»variable length packets, packet length configured by the first byte after sync word
	write_register(CC1101_ADDR,     0x00);		//address used for packet filtration.
	write_register(CC1101_PKTLEN,   0x3D); 	//61 bytes max length
}

static void setupread_cc1101(){
	uint8_t id;
	read_registers(CC1101_FSCTRL1, &id,1); 	printf("CC1101_FSCTRL1 	0x%2x\n", id);
	read_registers(CC1101_FSCTRL0, &id,1); 	printf("CC1101_FSCTRL0 	0x%2x\n", id);
	read_registers(CC1101_FREQ2, &id,1); 		printf("CC1101_FREQ2 	0x%2x\n", id);
	read_registers(CC1101_FREQ1, &id,1); 		printf("CC1101_FREQ1 	0x%2x\n", id);
	read_registers(CC1101_FREQ0, &id,1); 		printf("CC1101_FREQ0 	0x%2x\n", id);
	read_registers(CC1101_MDMCFG4, &id,1); 	printf("CC1101_MDMCFG4 	0x%2x\n", id);
	read_registers(CC1101_MDMCFG3, &id,1); 	printf("CC1101_MDMCFG3 	0x%2x\n", id);
	read_registers(CC1101_MDMCFG2, &id,1); 	printf("CC1101_MDMCFG2 	0x%2x\n", id);
	read_registers(CC1101_MDMCFG1, &id,1); 	printf("CC1101_MDMCFG1 	0x%2x\n", id);
	read_registers(CC1101_MDMCFG0, &id,1); 	printf("CC1101_MDMCFG0 	0x%2x\n", id);
	read_registers(CC1101_CHANNR, &id,1); 	printf("CC1101_CHANNR 0x%2x\n", id);
	read_registers(CC1101_DEVIATN, &id,1); 	printf("CC1101_DEVIATN 	0x%2x\n", id);
	read_registers(CC1101_FREND1, &id,1); 	printf("CC1101_FREND1 0x%2x\n", id);
	read_registers(CC1101_FREND0, &id,1); 	printf("CC1101_FREND0 0x%2x\n", id);
	read_registers(CC1101_MCSM0, &id,1); 		printf("CC1101_MCSM0 	0x%2x\n", id);
	read_registers(CC1101_FOCCFG, &id,1); 	printf("CC1101_FOCCFG 	0x%2x\n", id);
	read_registers(CC1101_BSCFG, &id,1); 		printf("CC1101_BSCFG 	0x%2x\n", id);
	read_registers(CC1101_AGCCTRL2, &id,1); printf("CC1101_AGCCTRL2 	0x%2x\n", id);
	read_registers(CC1101_AGCCTRL1, &id,1); printf("CC1101_AGCCTRL1 	0x%2x\n", id);
	read_registers(CC1101_AGCCTRL0, &id,1); printf("CC1101_AGCCTRL0 	0x%2x\n", id);
	read_registers(CC1101_FSCAL3, &id,1); printf("CC1101_FSCAL3 	0x%2x\n", id);
	read_registers(CC1101_FSCAL2, &id,1); printf("CC1101_FSCAL2 	0x%2x\n", id);
	read_registers(CC1101_FSCAL1, &id,1); printf("CC1101_FSCAL1 	0x%2x\n", id);
	read_registers(CC1101_FSCAL0, &id,1); printf("CC1101_FSCAL0 	0x%2x\n", id);
	read_registers(CC1101_FSTEST, &id,1); printf("CC1101_FSTEST 	0x%2x\n", id);
	read_registers(CC1101_TEST2, &id,1); printf("CC1101_TEST2 	0x%2x\n", id);
	read_registers(CC1101_TEST1, &id,1); printf("CC1101_TEST1 	0x%2x\n", id);
	read_registers(CC1101_TEST0, &id,1); printf("CC1101_TEST0		0x%2x\n", id);
	read_registers(CC1101_IOCFG2, &id,1); printf("CC1101_IOCFG2 	0x%2x\n", id);
	read_registers(CC1101_IOCFG0, &id,1); printf("CC1101_IOCFG0 	0x%2x\n", id);
	read_registers(CC1101_PKTCTRL1, &id,1); printf("CC1101_PKTCTRL1 	0x%2x\n", id);
	read_registers(CC1101_PKTCTRL0, &id,1); printf("CC1101_PKTCTRL0 	0x%2x\n", id);
	read_registers(CC1101_ADDR, &id,1); printf("CC1101_ADDR 	0x%2x\n", id);
	read_registers(CC1101_PKTLEN, &id,1); printf("CC1101_PKTLEN 	0x%2x\n", id);
}

// the main function
int main(){
	stdio_init_all();
	sleep_ms(5000);
	printf("Hello, Reading raw data from registers via SPI...\n");

	// initalise the required pins
	spi_init(spi0, 500 * 1000);
  gpio_set_function(SPI_RX_PIN, GPIO_FUNC_SPI);
  gpio_set_function(SPI_SCK_PIN, GPIO_FUNC_SPI);
  gpio_set_function(SPI_TX_PIN, GPIO_FUNC_SPI);

	bi_decl(bi_3pins_with_func(SPI_RX_PIN, SPI_TX_PIN, SPI_SCK_PIN, GPIO_FUNC_SPI));

	// Chip select is active-low, so we'll initialise it to a driven-high state
	gpio_init(SPI_CSN_PIN);
	gpio_set_dir(SPI_CSN_PIN, GPIO_OUT);
	gpio_put(SPI_CSN_PIN, 1);
	// Make the CS pin available to picotool
	bi_decl(bi_1pin_with_name(SPI_CSN_PIN, "SPI CS"));

	// See if SPI is working - interrograte the device for its I2C ID number, should be 0x60
	uint8_t id;
	while(1){
		setup_cc1101();
		setupread_cc1101();

		sleep_ms(3000);
	}
}

## Commit log (part)

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2022-01-11 Add running coverage on firmware test and build
2022-01-11 Run workflow if any file in the firmware folder is changed
2022-01-11 correct the name keyword
2022-01-11 remove a repeated run command
2022-01-11 add cpp code to create logs folder
2022-01-11 Add command to write out coverage data
2022-01-11 seperate out the testing results from fpga compling
2022-01-11 remove coverage stats from fpga stats comment
2022-01-11 retrive the vcd file
2022-01-12 Add tools to generate wavejson file
2022-01-12 add the wavedrom output into the pr comment
2022-01-12 formatting of the wavedrom command for the image
2022-01-12 change to use single quotes in json file
2022-01-12 reduce the counter size for the testing build
2022-01-13 Tidy up the schematic and add titles
2022-01-13 Update the hub75 connector with lables
2022-01-13 Add jjh logos and text description on the back on the PCB
2022-01-13 Swap A and B pins so they are in order for the RP2040 code
2022-01-13 update the pin numbers to match the hub75 interface board
2022-01-14 Add building instructions to the readme file
2022-01-15 Rename mountains to myimage
2022-01-17 Make so comments not added if not running as scheduled
2022-01-17 change to single quotation marks
2022-01-21 Add a empty readme file
2022-02-04 Add basic serial tx to test bench
2022-02-04 update to output multiple commands
2022-02-04 add per led test
2022-02-04 extend test length
2022-02-04 include all LEDs in the test
2022-02-06 Add a parameter based testing counter width
2022-02-06 remove unused function
2022-02-07 Add top level readme file for board
2022-02-07 Add a copy of the LED controller datasheet
2022-02-08 Update hardware to kicad6
2022-02-08 correct the file name
2022-02-08 fix some ERC and DRC errors in the schematic
2022-02-08 workflow only run on schedule or pull request
2022-02-11 add multicore, not working
2022-02-14 change serial to be output on usb
2022-02-14 basic example in top left
2022-02-14 add RGB colour to the output values
2022-02-14 Add ir_disp build
2022-02-14 Add build on software and correct sdk path
2022-02-19 improvement to readability
2022-02-19 write to every single pixel
2022-02-23 initial start of pcb layout
2022-02-23 Add the schematics for each of the 7 segment characters
2022-02-23 Add initial layout for segment 1
2022-02-23 minor changes to segments
2022-02-23 Add imporved controller symbol and pmod connector
2022-02-24 Create controller schematic sheet"
2022-02-24 include changes in moving controller to seperate sheet
2022-02-24 correct the bus naming
2022-02-24 start mapping out locations on PCB
2022-02-25 changes to the LED connection ordering
2022-02-25 update PCB with the schematic for first display
2022-02-26 update the pin layout on segment 2
2022-02-27 finish remapping the pins to the LEDs
2022-02-27 route the bus conections on SW to LEDs
2022-02-27 update the pin for segment 4 to improve pcb layout
2022-02-27 correct pins in schematic and continue LED layout on PCB
2022-02-27 continue with placement and layout of digits
2022-03-01 start writing the pixels input values
2022-03-02 add top, makefile, and finish off write pixels
2022-03-02 get basic test working for LED array
2022-03-02 Add workflow for the LED Array Firmware
2022-03-02 add python for wavedrom
2022-03-02 correct wave formate
2022-03-03 initial design of GPS Neo-M8M Pmod Board
2022-03-03 change 20ohms resistors to 4 way resistor arrays
2022-03-03 Remove software section copied in error
2022-03-03 add violation excpetion for erc antenna
2022-03-03 add driven flag to the antenna
2022-03-03 Add build status to the main README file
2022-03-03 improve signal routing
2022-03-03 change board clearance settings
2022-03-04 Start work in kicad v6 to add duel pmod version
2022-03-04 correct kicad file extensions
2022-03-04 update the pcb, complete connections and add logos
2022-03-04 add configurable pps length to simulation
2022-03-04 fix verilator error in top function
2022-03-04 correct the yosys command for building fpga image
2022-03-07 extend the length of the test
2022-03-07 Edit the counters
2022-03-08 working example using PMod1A connector
2022-03-08 Reduce the LED brightness
2022-03-08 fix bit width verilator warning
2022-03-08 fix linter issue with bit width
2022-03-08 Add basic 7 segment example in firmware
2022-03-08 remove un-needed outputs and output to both ports
2022-03-09 update output to include pmod2
2022-03-09 Add workflow file for 7 segment display
2022-03-09 Add run on firmware changes
2022-03-09 add blank line
2022-03-09 reorder pull request paths
2022-03-09 fix firmware job indentation
2022-03-10 Add functions for building the ECP5 firmware
2022-03-10 Add pin out file for the colorlite board
2022-03-10 Add ecp5 flash write option
2022-03-10 Add parameterisation
2022-03-12 Complete initial PCB layout
2022-03-12 Resolve some of the DRC errors on PCB
2022-03-12 Add fabrication file for kicad v6
2022-03-12 Correct file name
2022-03-12 update pcb to correct schematic error in bus connections
2022-03-12 Chane required clearance to 0.19mm from 0.2mm
2022-03-13 rename the folder for pmod rgb 7 segement folder
2022-03-13 update the workflow names
2022-03-13 Add the RGB 7 segment display to the Readme file
2022-03-13 Add join between the two PCB's
2022-03-14 Add power ports
2022-03-14 fix some drc errors with the PCB
2022-03-14 Improvements to reduce the number of drc errors
2022-03-14 minor pcb edits
2022-03-14 update the PCB to kicad v6
2022-03-14 upgrade workflow to v6
2022-03-14 sort out some pcb drc errors
2022-03-14 update workflow run on schedule and files to run on
2022-03-15 fix drc errors in ci
2022-03-20 colorlite bord imrpovements
2022-03-21 move elemets into pixel control
2022-03-28 add a thruwire example for GPS board
2022-03-28 Add a readme to the firmware folder
2022-04-09 removed read to run faster
2022-04-13 basic outline with cpp object for display
2022-04-18 Start mapping LED toe reg positions
2022-06-19 Add single digit counter
2022-06-19 save the simple version from before
2022-06-19 4 digit counter with gamma correction
2022-06-27 update the workflow file to kicad v6
2022-06-27 remove old format files
2022-06-27 update for schematic to pass erc
2022-06-27 Fix filename in workflow file
2022-06-27 remove space from the file name for software build
2022-06-27 Schematic visual improvements and add license
2022-06-27 upgrade to using version 2
2022-06-27 condense the code for setting segment that is on
2022-06-27 fix the limits on the color gradient
2022-06-27 code refactoring
2022-06-27 Add software build to the github action
2022-06-27 Add additional paths on pull request
2022-06-27 fix software build github action
2022-06-27 Swap PCB and Sch files name to be correct way round
2022-09-29 remove missing 3d model from part
2022-10-02 upgrade ti to kibot latest integration
2022-10-02 upgrade to to kibot latest github action integration
2022-10-02 remove old files
2022-10-02 add drc exclusion workarround
2022-10-03 test using v2 api
2022-10-03 outlines to start writing the rp2040 code
2022-10-03 start defining a simple forwarding solution
2022-10-03 Add 1pps display using on-board LED
2022-10-04 add string handling to find message
2022-10-04 add basic processing for time
2022-10-04 fix extracting the time from GPS data
2022-10-04 add leading zeros to the printf statements
2022-10-11 correct the error for the RX and TX being the wrong way round #73 on PCB
2022-10-11 Add Gitrev to PCB using github action
2022-10-11 correct spacing error
2022-10-11 rotate the text to match others
2022-10-11 change how to get short sha
2022-10-11 correct vairable name
2022-10-11 add debug of display full git sha hash
2022-10-11 Add debug info
2022-10-11 remove debugging
2022-10-11 change sha source
2022-10-11 fix closing sequence
2022-10-11 change debug format
2022-10-11 set as github varriable
2022-10-11 change git rev for pcb text
2022-10-11 change to verriable
2022-10-11 correct typo in command
2022-10-12 correct if syntax
2022-10-12 Add missing bracket
2022-10-12 Add simple processing for printing the date to the serial console
2022-10-12 start work on FPGA clock counter
2022-10-13 update to check the error in the test
2022-10-13 Adding serial output
2022-10-14 Add python script to read the error values
2022-11-10 add a countdown to christmas display
2022-11-10 add software build to gps
2022-11-10 correct the sdk path
2022-11-16 sort out LED and 1pps PMod pins
2022-11-23 correct the lon/lat value calculation
2022-11-23 improvements to include more elements
2022-12-05 correct the prossessing of the month data
2022-12-13 finish 1pps update change
2022-12-13 tidy up code
2022-12-20 change install dependancies
2022-12-20 increase verilator version 4.204->4.224
2022-12-20 back to verilator 4.204, as no deb avalible for newer verion
2022-12-20 apply fix to other firmware workflows
2022-12-30 update the power symbols
2022-12-30 test with kicad developmental version
2023-01-08 seperate out interpolation from color lookup
2023-01-08 look table improvements
2023-02-14 fix pip package name for yowasp
2023-02-15 change so runs on pushes to master
2023-02-15 change scheduled task to run everyday
2023-05-13 fix test warnings in verilator
2023-05-14 plotting audio signal on the LED array
2023-05-18 add config file to files to be removed in clean up
2023-05-19 changes to trigger running workflow
2023-05-19 blank space fixes
2023-05-19 change to use default verilator
2023-10-13 Add workflow dispact option
2023-10-13 edit workflow dispact option
2023-10-13 Correct file path for verilator deb file
2023-10-13 fix missed dependancy and force the install
2023-10-13 correct the data state value
2023-10-13 add rxuart to the ice40 firmware build
2023-10-14 Add debuging and fixes
2023-10-14 fix verilator errors
2023-10-14 rename the readme file
2023-10-14 Add github action details and python note
2023-12-01 update verilog version in workflow
2023-12-01 add apt update to workflow
2024-02-21 add initial kicad7 schematic files
2024-02-21 add power flags
2024-02-21 removal old kicad5 files
2024-02-21 update to kibot for kicad7
2024-02-21 change design rules for PCB
2024-02-21 change logo designator
2024-02-21 update cc1101 center pad to pin 21
2024-02-21 update project files
2024-02-23 change the workflow runs reasons
2024-02-23 update the kibot files
2024-02-23 update kibot version
2024-02-23 fix some pcb errors
2024-02-23 remove unconnected tracks
2024-02-23 remove old file
2024-02-23 change the logo reference
2024-02-25 import design rules from cc1101 board
2024-02-25 update the design rukes for thermal releif
2024-02-25 add erc libary error exculsion
2024-02-25 edit the design rules for libary error
2024-04-16 Change logo reference
2024-04-16 add designators to the mounting holes
2024-04-16 change the pr comment generator
2024-04-16 missing project file
2024-04-16 fix the LED PMod Workflow PR comments
2024-04-16 Change the logo references
2024-04-16 Move to kicad version 7
2024-04-16 Move to kicad project edits
2024-04-16 update the footprints
2024-04-16 Change LED desigantors
2024-04-16 remove ref** designators
2024-04-16 change pcb rules
2024-04-16 update pcb from schematic
2024-04-17 change the comments using in the workflow function
2024-04-17 add worklow dispat to run action
2024-04-17 update kicad to version 7
2024-09-23 update workflow to upload using v4
2024-09-23 add workflow dispatch option
2024-09-23 improve readability
2024-09-23 correct version of kibot used
2025-01-02 add changes so they could be used in Vivado
2025-04-11 update the required build tools for pico sdk
2025-04-11 changing define order
2025-04-11 update verilator version
2025-04-11 fix type error by removing underscore
2025-04-11 change pr commenting action
2025-06-13 starting work on the schematic
2025-06-13 schematic capture and board layout
2025-06-13 add hardware workflow
2025-06-13 Correct the filenames for kicad files
2025-06-13 update do not fit components
2025-06-13 update the do not fit settings
2025-06-13 update with cap part numbers for the bom
2025-06-14 use newer drc and erc setup
2025-06-14 fab version of the board
