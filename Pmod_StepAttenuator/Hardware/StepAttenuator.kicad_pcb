# Repository jjhorton/PMod

File README.md:

# PMod boards
A selection of Random PMod Boards to be used with FPGA's that use the Digilent PMod standard connection

# Board Status
The boards in the table are being checked using github actions [Kibot](https://github.com/INTI-CMNB/KiBot) for the KiCAD files and also building the example code for each one online. The fabrication files produced using Gitfub actions also includes a PDF of the schematic and GERBER files for getting PCB's built using [JLCPCB](https://jlcpcb.com).

| Board | Build Status | Description |
| --- | --- | --- |
| PMod 7 Segment Display |  | An 8 digit, 7 segment display |
| PMod CC1101 |  | sub-1GHz Transceiver board based on a CC1101 |
| PMod GPS |  | A board with a self contained GPS receiver and antenna | 
| PMod Hub75 |  | Forr connection Hub75 display using PMod |
| PMod Infrared Array |  | contains an 8x8 IR Thermal sensor |
| PMod LED |  | Contains 8 LED's which can be individually turned on and off |
| PMod LED Array |  | An Array of 128 LED in a 8 x 16 array |
| PMod NeoPixel |  | A board with 10 WS2812 RGB LED's |
| PMod NeoPixel Array |  | An array of 8x8 WS2812B LED's |
| PMod RGB 7 Segment Display |  | A 4 digit 7 segment display made out of RGB LED's |
| PMod Test Board |  | An inline board for debugging |

## KiCad design Pmod_StepAttenuator/Hardware/StepAttenuator.kicad_pcb

Parts:
C1: 0.1uf; C_0402_1005Metric; LCSC Part C1525
C2: 100pF; C_0402_1005Metric; LCSC Part C1546
J1: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Vertical; not fitted
J2, J3: Conn_Coaxial; SMA_Amphenol_132289_EdgeMount; not fitted
U1: PE4312C-Z; QFN-20_L4.0-W4.0-P0.50-BL-EP2.2; LCSC Part C500480

Connections:
+3V3: C1.1, C2.1, J1.11, J1.12, U1.6 (VDD), U1.9 (VDD)
Data_C1: J1.6, U1.19 (C1)
Data_C2: J1.3, U1.17 (C2)
Data_C4: J1.4, U1.16 (C4)
Data_C5: J1.5, U1.20 (C5)
Data_C8: J1.1, U1.15 (C8)
Data_C16: J1.2, U1.1 (C16)
GND: C1.2, C2.2, J1.9, J1.10, J2.2 (Ext), J3.2 (Ext), U1.7 (PUP1), U1.8 (PUP2), U1.10 (GND), U1.11 (GND), U1.12 (VSS/GND), U1.13 (PS), U1.18 (GND), U1.21 (GND)
LE: J1.7, U1.5 (LE)
unnamed: J2.1 (In), U1.14 (RFOUT)
unnamed: J3.1 (In), U1.2 (RFIN)

Notes on the sheet:
Both Power up state control pulled to ground, as not used
PS is pulled Low to enable the parellel interface.
Pin 12 pulled to ground to enable internal neg Voltage generator

Board: 4 copper layers, 29.0 x 22.0 mm, 6 parts (0 on the bottom side), 11 nets.

## KiCad design PMod_CC2500/Hardware/pmod_cc2500.kicad_pcb

Board: 4 copper layers, 40.0 x 17.0 mm, 17 parts (0 on the bottom side), 18 nets.

Parts:
C1, C2: C; C_0603_1608Metric
C3: 100nF; C_0603_1608Metric
C4, C5: 100pF; C_0603_1608Metric
C6, C7: 1pF; C_0603_1608Metric
C8: 1.8pF; C_0603_1608Metric
C9: 1.5pF; C_0603_1608Metric
J1: Conn_02x06_Counter_Clockwise; PinHeader_2x06_P2.54mm_Vertical
J2: Conn_Coaxial; SMA_Samtec_SMA-J-P-X-ST-EM1_EdgeMount
L1, L2, L3: 1.2nH; L_0603_1608Metric
R1: 56K; R_0603_1608Metric
U1: CC2500RGPR; QFN50P400X400X100-21N-D
XTAL1: 26MHz; Crystal_SMD_Abracon_ABM8G-4Pin_3.2x2.5mm

Connections:
+3V3: J1.11, J1.12, U1.4, U1.9, U1.11, U1.14, U1.15, U1.18
GDO0: J1.4, U1.6
GDO2: J1.3, U1.3
GND: C1.2, C2.2, C3.2, C6.1, C8.2, C9.2, J1.9, J1.10, J2.2, L1.2, R1.1, U1.16, U1.19, XTAL1.2, XTAL1.4
unnamed: C1.1, U1.8, XTAL1.1
unnamed: C2.1, U1.10, XTAL1.3
unnamed: C3.1, U1.5
unnamed: C4.1, C6.2, L2.2
unnamed: C4.2, U1.12
unnamed: C5.1, C7.2, L1.1
unnamed: C5.2, U1.13
unnamed: C7.1, C8.1, L2.1, L3.2
unnamed: C9.1, J2.1, L3.1
unnamed: R1.2, U1.17
SPI_CLK: J1.5, U1.1
SPI_CSN: J1.8, U1.7
SPI_RX: J1.7, U1.2
SPI_TX: J1.6, U1.20

## KiCad design PMod_7Segment/hardware/PMod_7Segement.kicad_pcb

Parts:
C1: 10uF; R_0603_1608Metric
DS1, DS2: LTC-5723HR; DIP1524W75P254L5030H825Q12N; Mouser Part Number 859-LTC-5723HR
J1: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Vertical
R1, R2: 10k; R_0603_1608Metric
U1: GN1640; SSOP-28_5.3x10.2mm_P0.65mm

Connections:
+3V3: C1.1, J1.11, J1.12, R1.1, R2.1, U1.17 (VDD)
/GRID1: DS1.12 (COMMON_K_(DIGIT_1)), U1.18 (GRID1)
/GRID2: DS1.9 (COMMON_K_(DIGIT_2)), U1.19 (GRID2)
/GRID3: DS1.8 (COMMON_K_(DIGIT_3)), U1.20 (GRID3)
/GRID4: DS1.6 (COMMON_K_(DIGIT_4)), U1.21 (GRID4)
/GRID5: DS2.12 (COMMON_K_(DIGIT_1)), U1.22 (GRID5)
/GRID6: DS2.9 (COMMON_K_(DIGIT_2)), U1.23 (GRID6)
/GRID7: DS2.8 (COMMON_K_(DIGIT_3)), U1.24 (GRID7)
/GRID8: DS2.6 (COMMON_K_(DIGIT_4)), U1.25 (GRID8)
/SEG1: DS1.11 (A_A), DS2.11 (A_A), U1.9 (SEG1)
/SEG2: DS1.7 (A_B), DS2.7 (A_B), U1.10 (SEG2)
/SEG3: DS1.4 (A_C), DS2.4 (A_C), U1.11 (SEG3)
/SEG4: DS1.2 (A_D), DS2.2 (A_D), U1.12 (SEG4)
/SEG5: DS1.1 (A_E), DS2.1 (A_E), U1.13 (SEG5)
/SEG6: DS1.10 (A_F), DS2.10 (A_F), U1.14 (SEG6)
/SEG7: DS1.5 (A_G), DS2.5 (A_G), U1.15 (SEG7)
/SEG8: DS1.3 (A_D.P.), DS2.3 (A_D.P.), U1.16 (SEG8)
CLK: J1.5, R1.2, U1.8 (CLK)
DATA: J1.7, R2.2, U1.7 (DATA)
GND: C1.2, J1.9, J1.10, U1.6 (GND)

Notes on the sheet:
Pull up Resistors
PMod Connector
Power Supply Capacitor

Board: 2 copper layers, 100.0 x 19.5 mm, 7 parts (4 on the bottom side), 20 nets.

## KiCad design PMod_LED/Hardware/PMod_LED.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24: LED; LED_0603_1608Metric
J1, J2, J3: Conn_02x06_Odd_Even; PinSocket_2x06_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24: 330; R_0603_1608Metric

Connections:
GND: D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), J2.9, J2.10, J3.9, J3.10
GND2: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), J1.9, J1.10
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2
unnamed: D5.2 (A), R5.2
unnamed: D6.2 (A), R6.2
unnamed: D7.2 (A), R7.2
unnamed: D8.2 (A), R8.2
unnamed: D9.2 (A), R9.2
unnamed: D10.2 (A), R10.2
unnamed: D11.2 (A), R11.2
unnamed: D12.2 (A), R12.2
unnamed: D13.2 (A), R13.2
unnamed: D14.2 (A), R14.2
unnamed: D15.2 (A), R15.2
unnamed: D16.2 (A), R16.2
unnamed: D17.2 (A), R17.2
unnamed: D18.2 (A), R18.2
unnamed: D19.2 (A), R19.2
unnamed: D20.2 (A), R20.2
unnamed: D21.2 (A), R21.2
unnamed: D22.2 (A), R22.2
unnamed: D23.2 (A), R23.2
unnamed: D24.2 (A), R24.2
P1_LED0: J1.8, R1.1
P1_LED1: J1.7, R2.1
P1_LED2: J1.6, R3.1
P1_LED3: J1.5, R4.1
P1_LED4: J1.4, R5.1
P1_LED5: J1.3, R6.1
P1_LED6: J1.2, R7.1
P1_LED7: J1.1, R8.1
P2A_LED0: J2.8, R9.1
P2A_LED1: J2.7, R10.1
P2A_LED2: J2.6, R11.1
P2A_LED3: J2.5, R12.1
P2A_LED4: J2.4, R13.1
P2A_LED5: J2.3, R14.1
P2A_LED6: J2.2, R15.1
P2A_LED7: J2.1, R16.1
P2B_LED0: J3.8, R17.1
P2B_LED1: J3.7, R18.1
P2B_LED2: J3.6, R19.1
P2B_LED3: J3.5, R20.1
P2B_LED4: J3.4, R21.1
P2B_LED5: J3.3, R22.1
P2B_LED6: J3.2, R23.1
P2B_LED7: J3.1, R24.1

Board: 2 copper layers, 25.4 x 60.9 mm, 93 parts (3 on the bottom side), 50 nets.

Other parts of the board:
HOLE1, HOLE2, HOLE3, HOLE4, HOLE5, HOLE6, HOLE7, HOLE8, HOLE9, HOLE10: NPTH
Logo1, Logo4: LOGO; j2h_small
Logo2, Logo5: OSHW-Logo2_7.3x6mm_SilkScreen
Logo3: LOGO; Untitled
kibuzzard-62214D6E: LED; kibuzzard-62214D6E
kibuzzard-62214D6E#2: G***; kibuzzard-62214D6E
kibuzzard-62214D8E: G***; kibuzzard-62214D8E
kibuzzard-62214D8E#2: LED; kibuzzard-62214D8E
kibuzzard-62214D9F: LED; kibuzzard-62214D9F
kibuzzard-62214D9F#2: G***; kibuzzard-62214D9F
kibuzzard-62214D83: G***; kibuzzard-62214D83
kibuzzard-62214D83#2: LED; kibuzzard-62214D83
kibuzzard-62214DA9: LED; kibuzzard-62214DA9
kibuzzard-62214DA9#2: G***; kibuzzard-62214DA9
kibuzzard-62214DB4: LED; kibuzzard-62214DB4
kibuzzard-62214DB4#2: G***; kibuzzard-62214DB4
kibuzzard-62214DC1: G***; kibuzzard-62214DC1
kibuzzard-62214DC1#2: LED; kibuzzard-62214DC1
kibuzzard-62214DCC: LED; kibuzzard-62214DCC
kibuzzard-62214DCC#2: G***; kibuzzard-62214DCC
kibuzzard-62214EC6: G***; kibuzzard-62214EC6
kibuzzard-62214ED8: G***; kibuzzard-62214ED8
kibuzzard-62214EE5: G***; kibuzzard-62214EE5
kibuzzard-62214EF3: G***; kibuzzard-62214EF3
kibuzzard-62214F07: G***; kibuzzard-62214F07
kibuzzard-62214F11: G***; kibuzzard-62214F11
kibuzzard-62214F38: G***; kibuzzard-62214F38
kibuzzard-62214F50: G***; kibuzzard-62214F50
kibuzzard-622155A9: Logo7; kibuzzard-622155A9
kibuzzard-62215596: Logo6; kibuzzard-62215596
kibuzzard-62215645: Logo8; kibuzzard-62215645

## KiCad design PMod_LEDArray/Hardware/PMOD_LEDArray.kicad_pcb

Parts:
C1: 100uF; C_0603_1608Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D95, D96, D97, D98, D99, D100, D101, D102, D103, D104, D105, D106, D107, D108, D109, D110, D111, D112, D113, D114, D115, D116, D117, D118, D119, D120, D121, D122, D123, D124, D125, D126, D127, D128: LED; LED_0603_1608Metric
J1: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Vertical
R1, R2: 10k; R_0603_1608Metric
U1: GN1640; TM1640

Connections:
+3V3: C1.1, J1.11, J1.12, R1.1, R2.1, U1.17 (VDD)
/GRID1: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), U1.18 (GRID1)
/GRID2: D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), U1.19 (GRID2)
/GRID3: D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U1.20 (GRID3)
/GRID4: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), U1.21 (GRID4)
/GRID5: D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), U1.22 (GRID5)
/GRID6: D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), U1.23 (GRID6)
/GRID7: D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), U1.24 (GRID7)
/GRID8: D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (K), D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), U1.25 (GRID8)
/GRID9: D65.1 (K), D66.1 (K), D67.1 (K), D68.1 (K), D69.1 (K), D70.1 (K), D71.1 (K), D72.1 (K), U1.26 (GRID9)
/GRID10: D73.1 (K), D74.1 (K), D75.1 (K), D76.1 (K), D77.1 (K), D78.1 (K), D79.1 (K), D80.1 (K), U1.27 (GRID10)
/GRID11: D81.1 (K), D82.1 (K), D83.1 (K), D84.1 (K), D85.1 (K), D86.1 (K), D87.1 (K), D88.1 (K), U1.28 (GRID11)
/GRID12: D89.1 (K), D90.1 (K), D91.1 (K), D92.1 (K), D93.1 (K), D94.1 (K), D95.1 (K), D96.1 (K), U1.1 (GRID12)
/GRID13: D97.1 (K), D98.1 (K), D99.1 (K), D100.1 (K), D101.1 (K), D102.1 (K), D103.1 (K), D104.1 (K), U1.2 (GRID13)
/GRID14: D105.1 (K), D106.1 (K), D107.1 (K), D108.1 (K), D109.1 (K), D110.1 (K), D111.1 (K), D112.1 (K), U1.3 (GRID14)
/GRID15: D113.1 (K), D114.1 (K), D115.1 (K), D116.1 (K), D117.1 (K), D118.1 (K), D119.1 (K), D120.1 (K), U1.4 (GRID15)
/GRID16: D121.1 (K), D122.1 (K), D123.1 (K), D124.1 (K), D125.1 (K), D126.1 (K), D127.1 (K), D128.1 (K), U1.5 (GRID16)
/SEG1: D8.2 (A), D16.2 (A), D24.2 (A), D32.2 (A), D40.2 (A), D48.2 (A), D56.2 (A), D64.2 (A), D72.2 (A), D80.2 (A), D88.2 (A), D96.2 (A), D104.2 (A), D112.2 (A), D120.2 (A), D128.2 (A), U1.9 (SEG1)
/SEG2: D7.2 (A), D15.2 (A), D23.2 (A), D31.2 (A), D39.2 (A), D47.2 (A), D55.2 (A), D63.2 (A), D71.2 (A), D79.2 (A), D87.2 (A), D95.2 (A), D103.2 (A), D111.2 (A), D119.2 (A), D127.2 (A), U1.10 (SEG2)
/SEG3: D6.2 (A), D14.2 (A), D22.2 (A), D30.2 (A), D38.2 (A), D46.2 (A), D54.2 (A), D62.2 (A), D70.2 (A), D78.2 (A), D86.2 (A), D94.2 (A), D102.2 (A), D110.2 (A), D118.2 (A), D126.2 (A), U1.11 (SEG3)
/SEG4: D5.2 (A), D13.2 (A), D21.2 (A), D29.2 (A), D37.2 (A), D45.2 (A), D53.2 (A), D61.2 (A), D69.2 (A), D77.2 (A), D85.2 (A), D93.2 (A), D101.2 (A), D109.2 (A), D117.2 (A), D125.2 (A), U1.12 (SEG4)
/SEG5: D4.2 (A), D12.2 (A), D20.2 (A), D28.2 (A), D36.2 (A), D44.2 (A), D52.2 (A), D60.2 (A), D68.2 (A), D76.2 (A), D84.2 (A), D92.2 (A), D100.2 (A), D108.2 (A), D116.2 (A), D124.2 (A), U1.13 (SEG5)
/SEG6: D3.2 (A), D11.2 (A), D19.2 (A), D27.2 (A), D35.2 (A), D43.2 (A), D51.2 (A), D59.2 (A), D67.2 (A), D75.2 (A), D83.2 (A), D91.2 (A), D99.2 (A), D107.2 (A), D115.2 (A), D123.2 (A), U1.14 (SEG6)
/SEG7: D2.2 (A), D10.2 (A), D18.2 (A), D26.2 (A), D34.2 (A), D42.2 (A), D50.2 (A), D58.2 (A), D66.2 (A), D74.2 (A), D82.2 (A), D90.2 (A), D98.2 (A), D106.2 (A), D114.2 (A), D122.2 (A), U1.15 (SEG7)
/SEG8: D1.2 (A), D9.2 (A), D17.2 (A), D25.2 (A), D33.2 (A), D41.2 (A), D49.2 (A), D57.2 (A), D65.2 (A), D73.2 (A), D81.2 (A), D89.2 (A), D97.2 (A), D105.2 (A), D113.2 (A), D121.2 (A), U1.16 (SEG8)
CLK: J1.5, R2.2, U1.8 (CLK)
DATA: J1.7, R1.2, U1.7 (DATA)
GND: C1.2, J1.9, J1.10, U1.6 (GND)

Board: 2 copper layers, 90.5 x 26.5 mm, 139 parts (1 on the bottom side), 28 nets.

Other parts of the board:
H1, H2, H3, H4: MountingHole_2.2mm_M2
LOGO1: LOGO; Untitled
Logo2: LOGO; j2h_small

## KiCad design PMod_Infrared_Array/Hardware/PMod_Infrared_Array.kicad_pcb

Parts:
C1: 0.1u; C_0603_1608Metric
C2: 10u; C_0603_1608Metric
C3: 1.5u; C_0603_1608Metric
C4: 1u; C_0603_1608Metric
D1, D2: LED; LED_0603_1608Metric
IC1: AMG8834; Mouser Part Number 667-AMG8834
J1: Conn_02x06_Counter_Clockwise; PinHeader_2x06_P2.54mm_Vertical
R1, R2: 330; R_0603_1608Metric
R3, R4, R5: 10K; R_0603_1608Metric
R6: 10k; R_0603_1608Metric
R7: 20; R_0603_1608Metric
R8: 0; R_0603_1608Metric

Connections:
+3V3: C1.1, C2.1, IC1.9 (VDD), IC1.13 (VPP), J1.11, J1.12, R3.1, R4.1, R5.1, R6.1
GND: C1.2, C2.2, C3.2, D1.1 (K), D2.1 (K), IC1.6 (GND), J1.9, J1.10, R7.2, R8.2
INT: IC1.4 (INT), J1.6, R5.2
LED0: J1.1, R1.1
LED1: J1.2, R2.1
unnamed: C4.2, R7.1
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: IC1.5 (AD_SELECT), R6.2, R8.1
unnamed: C4.1, IC1.10 (AVDD-PC)
unnamed: C3.1, IC1.12 (DVDD-PC)
SCL: IC1.3 (SCL), J1.8, R4.2
SDA: IC1.2 (SDA), J1.7, R3.2

Notes on the sheet:
Decoupling
VPP Decoupling
Status LED 1
Value for VDD Decoupling Capasitor taken from Datashet
Value for Vpp Decoupling taken from Datashet
SDA and SCL are placed to match the outputs on the Pico PMod host board, so it can easily be used with that board.
With I2C Address: 1101000 Without I2C Address: 1101001
PMod Connector
VDD Decoupling
Status LED 0

Board: 2 copper layers, 50.0 x 18.0 mm, 17 parts (1 on the bottom side), 13 nets.

Other parts of the board:
L1: LOGO; Untitled

## KiCad design PMod_CC1101/Hardware/cc1101.kicad_pcb

File PMod_CC1101/Hardware/README.md:

# CC1101

The KiCAD PMOD design for the cc1101 board on a pmod connector

Board: 4 copper layers, 40.5 x 17.0 mm, 19 parts (1 on the bottom side), 19 nets.

Parts:
C51: 100nF; C_0603_1608Metric
C81, C101: 27pF; C_0603_1608Metric
C121, C131: 3.9pF; C_0603_1608Metric
C122: 8.2pF; C_0603_1608Metric
C123: 5.6pF; C_0603_1608Metric
C124, C125: 220pF; C_0603_1608Metric
J1: Conn_Coaxial; SMA_Samtec_SMA-J-P-X-ST-EM1_EdgeMount
J2: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Vertical
L121, L123, L131: 27nH; L_0603_1608Metric
L122: 22nH; L_0603_1608Metric
Logo1: LOGO; Untitled
R171: 56K; R_0603_1608Metric
U1: CC1101RGPR; QFN50P400X400X100-21N-D
XTAL1: 26MHz; Crystal_SMD_Abracon_ABM3C-4Pin_5.0x3.2mm

Connections:
+3V3: J2.11, J2.12, U1.4 (DVDD), U1.9 (AVDD), U1.11 (AVDD), U1.14 (AVDD), U1.15 (AVDD), U1.18 (DGUARD)
GDO0: J2.4, U1.6 (GDO0)
GDO2: J2.3, U1.3 (GDO2)
GND: C51.1, C81.2, C101.1, C122.2, C123.2, C124.2, C131.1, J1.2 (Ext), J2.9, J2.10, R171.1, U1.16 (GND), U1.19 (GND), U1.21 (GND), XTAL1.2, XTAL1.4
unnamed: C121.1, L122.1, L131.2
unnamed: C122.1, L122.2, L123.1
unnamed: C123.1, C125.2, L123.2
unnamed: C124.1, L121.1
unnamed: C125.1, J1.1 (In)
unnamed: C51.2, U1.5 (DCOUPL)
unnamed: R171.2, U1.17 (RBIAS)
unnamed: C131.2, L131.1, U1.13 (RF_N)
unnamed: C121.2, L121.2, U1.12 (RF_P)
unnamed: C81.1, U1.8 (XOSC_Q1), XTAL1.3
unnamed: C101.2, U1.10 (XOSC_Q2), XTAL1.1
SPI_CLK: J2.5, U1.1 (SCLK)
SPI_CSN: J2.8, U1.7 (CSn)
SPI_RX: J2.7, U1.2 (SO(GDO1))
SPI_TX: J2.6, U1.20 (SI)
